Commit message: exercise updated

File: urdf/robot1_arm.urdf (robot description, URDF)
Before this commit: robot Robot1, 6 links, 5 joints
Joints:
- joint arm_1_to_arm_base: origin xyz=0 0 0.15 -> xyz=0 0 0.1
- joint base_to_arm_base: origin xyz=0 0 0 -> xyz=0 0 0.035
